# Keil uVision project 红外舵机.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 红外舵机4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lcd.c 遥控器控制马达.c lcd.h lcd1602.c public.c 矩阵按键.c JZAJ.h lcd1602.h public.h iic.c 24c02.c 24c02.h iic.h
